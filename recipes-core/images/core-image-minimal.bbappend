IMAGE_INSTALL:append = " \
	usbutils \
	util-linux \
"
